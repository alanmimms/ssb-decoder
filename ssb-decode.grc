options:
  parameters:
    author: alan
    description: Get sample data from https://www.sdrplay.com/iq-demo-files/
    generate_options: qt_gui
    id: ssb_decoder
    output_language: python
    title: SSB decoder
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: rf_decim
  id: variable
  parameters:
    value: '30'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '333333'
  states: {}
- name: sideband
  id: variable_qtgui_chooser
  parameters:
    label: Sideband
    label0: USB
    label1: LSB
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '1'
  states: {}
- name: ssb_factor
  id: variable
  parameters:
    value: '-1.0  if sideband != 0 else 1.0'
  states: {}
- name: tune
  id: variable_qtgui_range
  parameters:
    label: Tune
    start: '-250000'
    step: '100'
    stop: '250000'
    value: '-40000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: sideband
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {state: disabled}
- name: blocks_swapiq_0
  id: blocks_swapiq
  parameters: {}
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/alan/ham/sample-iq-data/40m/SDRuno_20200912_004330Z_7150kHz.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tune
    decim: rf_decim
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(rf_gain, samp_rate, -3500, -200, 100) if sideband != 0 else firdes.complex_band_pass(rf_gain, samp_rate, 200, 3500, 100)
    type: ccc
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '1024'
    name: '"AF"'
    plotconst: 'False'
    plotfreq: 'False'
    plottime: 'False'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    name: '"RF"'
    plotconst: 'False'
    plotfreq: 'False'
    plottime: 'False'
    rate: '50'
    type: complex
  states: {}
- name: qtgui_sink_x_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    name: '"baseband"'
    plotconst: 'False'
    plotfreq: 'False'
    plottime: 'False'
    rate: '50'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/rf_decim)
    interp: '48000'
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: baseband
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: baseband
  states: {}

connections:
- [analog_agc2_xx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_complex_to_real_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_sink_x_0, '0']
- [blocks_selector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_swapiq_0, '0', blocks_selector_0, '1']
- [blocks_throttle2_0, '0', analog_agc2_xx_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_1, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_sink_x_1_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', virtual_sink_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [virtual_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', blocks_selector_0, '0']
- [virtual_source_0, '0', blocks_swapiq_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
