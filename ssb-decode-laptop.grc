options:
  parameters:
    author: alan
    generate_options: qt_gui
    id: ssb_decoder
    output_language: python
    title: SSB decoder
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: decim_samp_rate
  id: variable
  parameters:
    value: samp_rate/5
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '0.1'
    stop: '100'
    value: '66'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '300000'
  states: {}
- name: sideband
  id: variable_qtgui_chooser
  parameters:
    label: Sideband
    label0: USB
    label1: LSB
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '1'
  states: {}
- name: sideband_filter
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '3500'
    low_cutoff_freq: '300'
    samp_rate: audio_rate
    type: complex_band_pass
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: tune
  id: variable_qtgui_range
  parameters:
    label: Tune
    start: '-250000'
    step: '100'
    stop: '250000'
    value: '-40000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.1'
    stop: '10'
    value: '6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: tune
    sample_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: sideband
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_swapiq_0
  id: blocks_swapiq
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/alan/ham/sample-iq-data/40m/SDRuno_20200912_004330Z_7150kHz.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: '3500'
    decim: '1'
    gain: rf_gain
    samp_rate: audio_rate
    type: ccc
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '1024'
    plotconst: 'False'
    plottime: 'False'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    name: '"RF"'
    plotconst: 'False'
    plottime: 'False'
    rate: '50'
    type: complex
  states: {}
- name: qtgui_sink_x_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    name: '"baseband"'
    plotconst: 'False'
    plotfreq: 'False'
    plottime: 'False'
    rate: '50'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: audio_rate
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: baseband
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: baseband
  states: {}

connections:
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_freqshift_cc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_selector_0, '0', blocks_complex_to_real_0, '0']
- [blocks_selector_0, '0', qtgui_sink_x_0, '0']
- [blocks_swapiq_0, '0', blocks_selector_0, '1']
- [blocks_throttle2_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_1, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [filter_fft_low_pass_filter_0, '0', qtgui_sink_x_1_0, '0']
- [filter_fft_low_pass_filter_0, '0', virtual_sink_0, '0']
- [rational_resampler_xxx_0, '0', filter_fft_low_pass_filter_0, '0']
- [virtual_source_0, '0', blocks_selector_0, '0']
- [virtual_source_0, '0', blocks_swapiq_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
